# IAR project p_vbt6.ewp, settings and files
configuration p_vbt6 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCDiagSuppress: pa050
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/sd3088; ../Drivers/sh1106; ../Drivers/ds18b20; ../Drivers/Keypad; ../Drivers/u8glib; ../Drivers/M2tklib; ../Drivers/max6675; ../Drivers/Ir
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: p_vbt6.srec
  ILINK.IlinkOutputFile: p_vbt6.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_ReportCheckFailed=__iar_ReportCheckFailedStdout
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s startup_stm32f103xb.s
  group Application/User
    ../Src/: allert_message.c dma.c freertos.c gpio.c i2c.c main.c menu.c queue_log.c ReportCheckFailedStdout.c spi.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_TIM.c stm32f1xx_it.c ticker.c tim.c triac.c u8g_arm.c usart.c user.c utils.c dma.c gpio.c usart.c tim.c stm32f1xx_hal_timebase_TIM.c freertos.c spi.c main.c i2c.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c system_stm32f1xx.c
  group Drivers/ds18b20
    ../Drivers/ds18b20/: ds18b20.c
  group Drivers/Ir
    ../Drivers/Ir/: ir.c
  group Drivers/Keypad
    ../Drivers/Keypad/: keypad.c
  group Drivers/m2tklib
    ../Drivers/M2tklib/: m2.c m2align.c m2dfs.c m2draw.c m2eh2bd.c m2eh2bs.c m2eh4bd.c m2eh4bs.c m2eh6bs.c m2ehts.c m2el2lmenu.c m2elalign.c m2elbutton.c m2elbuttonptr.c m2elcombo.c m2elcombofn.c m2elcomboptr.c m2elfnfmt.c m2elhide.c m2elinfo.c m2ellabel.c m2ellabelfn.c m2ellabelp.c m2ellabelptr.c m2ellistbase.c m2ellistcalc.c m2ellistgrid.c m2ellisth.c m2ellistv.c m2ellistxy.c m2elradio.c m2elroot.c m2els8base.c m2els8num.c m2elsb.c m2elsetval.c m2elslbase.c m2elspace.c m2elstr.c m2elstrlist.c m2elstrptr.c m2elstrup.c m2elsubutl.c m2eltext.c m2eltoggle.c m2eltsk.c m2elu32.c m2elu8base.c m2elu8hs.c m2elu8num.c m2elxbm.c m2esarmu8g.c m2fnarg.c m2gfx.c m2gfxutl.c m2ghdummy.c m2ghu8gbf.c m2ghu8gbfs.c m2ghu8gcffs.c m2ghu8gfb.c m2ghu8gffs.c m2ghu8gicon.c m2ghu8gutl.c m2key.c m2msg.c m2navdatadn.c m2navdataup.c m2navfirst.c m2navinit.c m2navlast.c m2navnext.c m2navprev.c m2navroot.c m2navupdn.c m2navutl.c m2null.c m2obj.c m2opt.c m2pin.c m2qk.c m2rom.c m2usrnext.c m2usrprev.c m2usrupdn.c m2utls8d.c m2utlstrdat.c m2utlu8d.c mas.c mas_sim.c pq.c
  group Drivers/max6675
    ../Drivers/max6675/: max6675.c
  group Drivers/sd3088
    ../Drivers/sd3088/: sd3088.c
  group Drivers/sh1106
    ../Drivers/sh1106/: sh1106.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash_ex.c
  group Drivers/u8glib
    ../Drivers/u8glib/: u8g.h u8g_bitmap.c u8g_circle.c u8g_clip.c u8g_com_api.c u8g_com_api_16gr.c u8g_com_io.c u8g_com_null.c u8g_com_std_sw_spi.c u8g_cursor.c u8g_delay.c u8g_dev_ssd1306_128x64.c u8g_ellipse.c u8g_font.c u8g_font_data.c u8g_line.c u8g_ll_api.c u8g_page.c u8g_pb.c u8g_pb14v1.c u8g_pb16h1.c u8g_pb16h2.c u8g_pb16v1.c u8g_pb16v2.c u8g_pb32h1.c u8g_pb8h1.c u8g_pb8h1f.c u8g_pb8h2.c u8g_pb8h8.c u8g_pb8v1.c u8g_pb8v2.c u8g_polygon.c u8g_rect.c u8g_rot.c u8g_scale.c u8g_state.c u8g_u16toa.c u8g_u8toa.c u8g_virtual_screen.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c tasks.c queue.c croutine.c event_groups.c list.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s portasm.s port.c
